# Keil uVision project DJISDK.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DJISDK +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407ZETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407ZETx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 4.3.0, Device:STM32Cube HAL:CAN 1.4.0, Device:STM32Cube HAL:CRC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:I2C 1.4.0, Device:STM32Cube HAL:NAND 1.4.0, Device:STM32Cube HAL:PC Card 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:RNG 1.4.0, Device:STM32Cube HAL:SD 1.4.0, Device:STM32Cube HAL:SPI 1.4.0, Device:STM32Cube HAL:SRAM 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:STM32Cube HAL:USART 1.4.0, Device:Startup 2.4.0
