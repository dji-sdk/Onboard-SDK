# Keil uVision project OnBoardSDK_STM32.uvprojx, settings and files
target DJI_LIB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: osdk_stm32 +hex
  c flags: Optim=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,STM32,STM32F40x,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --exceptions --cpp11
  c include: ..\Lib\CMSIS\inc;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Bsp;..\..\..\..\..\osdk-core\api\inc;..\..\..\..\..\osdk-core\hal\inc;..\..\..\..\..\osdk-core\protocol\inc;..\..\..\..\..\osdk-core\platform\STM32\inc;..\..\..\..\..\osdk-core\utility\inc;..\..\..\..\..\osdk-core\platform\default\inc;..\..\..\..\core\inc;..\..\..\..\..\osdk-core\modules\inc;..\..\..\..\..\osdk-core\modules\inc\payload;..\..\..\..\..\osdk-core\modules\inc\flight;..\..\..\..\..\osdk-core\linker\core\channel;..\..\..\..\..\osdk-core\linker\core\command;..\..\..\..\..\osdk-core\linker\core\logger;..\..\..\..\..\osdk-core\linker\core\platform;..\..\..\..\..\osdk-core\linker\core\protocol;..\..\..\..\..\osdk-core\linker\core\root_task;..\..\..\..\..\osdk-core\linker\core\utils\inc;..\..\..\..\..\osdk-core\platform\inc;..\..\..\..\..\osdk-core\logger\inc;..\..\..\..\..\osdk-core\linker\core;..\..\..\..\..\osdk-core\linker;..\OS\FreeRTOS\include;..\OS\FreeRTOS\portable\RVDS\ARM_CM4F;..\Linker\hal;..\Linker\osal
  asm misc: --exceptions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: cppforstm32.cpp main.cpp FlightControlSample.cpp MissionSample.cpp CameraGimbalSample.cpp MobileSample.cpp TelemetrySample.cpp Activate.cpp Receive.cpp TimeSyncSample.cpp PayloadSample.cpp CameraManagerSample.cpp dji_stm32_helpers.cpp
    ../../../../core/src/: camera_manager_async_sample.cpp
  group Bsp
    ../Bsp/: BspUsart.cpp timer.cpp bsp.cpp
  group doc
    ../doc/: readme.txt
  group LIB
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Lib/CMSIS/src/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DJIlib
    ../../../../../osdk-core/api/src/: dji_camera_manager.cpp dji_ack.cpp dji_broadcast.cpp dji_camera.cpp dji_command.cpp dji_control.cpp dji_error.cpp dji_gimbal.cpp dji_hardware_sync.cpp dji_hotpoint.cpp dji_mfio.cpp dji_mission_manager.cpp dji_mobile_communication.cpp dji_mobile_device.cpp dji_payload_device.cpp dji_subscription.cpp dji_vehicle.cpp dji_version.cpp dji_virtual_rc.cpp dji_waypoint.cpp dji_flight_controller.cpp dji_psdk_manager.cpp dji_legacy_linker.cpp
    ../../../../../osdk-core/modules/src/payload/: dji_camera_module.cpp dji_psdk_module.cpp dji_payload_base.cpp dji_payload_link.cpp
    ../../../../../osdk-core/utility/src/: dji_singleton.cpp
    ../../../../../osdk-core/modules/src/flight/: dji_flight_actions_module.cpp dji_flight_assistant_module.cpp dji_flight_link.cpp
    ../../../../../osdk-core/platform/src/: dji_platform.cpp
    ../../../../../osdk-core/logger/src/: dji_log.cpp
  group Linker
    ../../../../../osdk-core/linker/core/channel/: osdk_channel.c
    ../../../../../osdk-core/linker/core/command/: osdk_command.c osdk_command_instance.c
    ../../../../../osdk-core/linker/core/logger/: osdk_logger.c
    ../../../../../osdk-core/linker/core/platform/: osdk_hal.c osdk_osal.c
    ../../../../../osdk-core/linker/core/protocol/: osdk_protocol.c osdk_protocol_sdk.c osdk_protocol_v1.c
    ../../../../../osdk-core/linker/core/root_task/: osdk_root_task.c
    ../../../../../osdk-core/linker/: dji_linker.cpp
  group Utils
    ../../../../../osdk-core/linker/core/utils/src/: osdk_buffer.c osdk_crc.c osdk_list.c osdk_md5.c osdk_msgq.c osdk_str.c osdk_unit.c osdk_work.c dji_aes.c
  group FreeRTOS_CORE
    ../OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_PORTABLE
    ../OS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../OS/FreeRTOS/portable/MemMang/: heap_4.c
  group Osal
    ../Linker/osal/: osdkosal_stm32.c
  group Hal
    ../Linker/hal/: osdkhal_stm32.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
