# Keil uVision project osdk-core.uvprojx, settings and files
target OSDK_LIB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: osdk-core (library)
  c flags: Optim=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32
  c misc: --exceptions --cpp11
  c include: ..\..\osdk-core;..\api\inc;..\linker;..\linker\core\channel;..\linker\core\command;..\linker\core\logger;..\linker\core\platform;..\linker\core\protocol;..\linker\core\root_task;..\linker\core\utils\inc;..\logger\inc;..\modules\inc\flight;..\modules\inc\payload;..\platform\inc;..\utility\inc;..\linker\core;..\..\sample\platform\STM32\OnBoardSDK_STM32\Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\sample\platform\STM32\OnBoardSDK_STM32\Lib\CMSIS\inc;..\..\sample\platform\STM32\OnBoardSDK_STM32\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group API
    ../api/src/: dji_ack.cpp dji_broadcast.cpp dji_camera.cpp dji_camera_manager.cpp dji_command.cpp dji_control.cpp dji_error.cpp dji_flight_controller.cpp dji_gimbal.cpp dji_gimbal_manager.cpp dji_hardware_sync.cpp dji_hotpoint.cpp dji_legacy_linker.cpp dji_mfio.cpp dji_mission_manager.cpp dji_mobile_device.cpp dji_payload_device.cpp dji_psdk_manager.cpp dji_subscription.cpp dji_vehicle.cpp dji_version.cpp dji_virtual_rc.cpp dji_waypoint.cpp
  group Modules
    ../modules/src/payload/: dji_camera_module.cpp dji_gimbal_module.cpp dji_payload_base.cpp dji_payload_link.cpp dji_psdk_module.cpp
    ../modules/src/flight/: dji_flight_actions_module.cpp dji_flight_assistant_module.cpp dji_flight_joystick_module.cpp dji_flight_link.cpp
  group Linker
    ../linker/: dji_linker.cpp
    ../linker/core/channel/: osdk_channel.c
    ../linker/core/command/: osdk_command.c osdk_command_instance.c
    ../linker/core/logger/: osdk_logger.c
    ../linker/core/platform/: osdk_hal.c osdk_osal.c
    ../linker/core/protocol/: osdk_protocol.c osdk_protocol_sdk.c osdk_protocol_usbmc.c osdk_protocol_v1.c
    ../linker/core/root_task/: osdk_root_task.c
    ../linker/core/utils/src/: dji_aes.c osdk_buffer.c osdk_crc.c osdk_list.c osdk_md5.c osdk_msgq.c osdk_str.c osdk_unit.c osdk_work.c
  group Others
    ../logger/src/: dji_log.cpp
    ../platform/src/: dji_platform.cpp
    ../utility/src/: dji_setup_helpers.cpp dji_singleton.cpp
